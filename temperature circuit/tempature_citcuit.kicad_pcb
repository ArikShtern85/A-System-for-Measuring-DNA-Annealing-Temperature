# Repository ArikShtern85/A-System-for-Measuring-DNA-Annealing-Temperature

File README.md:

# A-System-for-Measuring-DNA-Annealing-Temperature

Hello and welcome to my project!

Overview
The purpose of this project is to create a system for measureing DNA annealing temperature. essentially, the measurment is done by warming and cooling a DNA sample and monitoring the changes in its fluorescence levels.

The project is based on an exsiting outdated and improves it by focusing on two main parts:
1. Production - manufacturing PCBs to replace the Breadboards which carried the required electronic circuitry, in order to improve the systems reliability and noise immunity.
2. software - creating a Graphic User Interface using MATLAB instead the existing LABVIEW one. 

Features
We manufactured two PCBs - Timing circuit and Temperature Circuit. 
the repo holds a folder for each circuit which we built and a powerpoint presentation in hebrew which explains the project:
1. Temperature circuit folder.
2. Timing (Lock In Detection) circuit folder.
3. Project presentation (in hebrew).

All the relevant Kicad files for each of the two circuits which we built are organized in the the relevant folder.

Setup and Installation
In order to view the Kicad files:
1. download Kicad from https://kicad.org/download/
2. download the files from the repo.
3. open the .pro inside to view the PCBs scheme, layout etc

Credits
This project was made together with my partner Leor Atzitz and under the guidance of Prof. Arye Weiss, faculty of engineering, Bar Ilan university.

## KiCad design temperature circuit/tempature_citcuit.kicad_pcb

Board: 2 copper layers, 79 parts (0 on the bottom side), 44 nets.

Parts:
9V1: testpoint07; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
9V2: testpoint08; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
C0, C1, C2: 4.7u; CP_Radial_D5.0mm_P2.50mm
C3, C4, C5: 10u; CP_Radial_D5.0mm_P2.50mm
Dzener_0, Dzener_1, Dzener_2: LM4040DBZ-2.5; TO-92L_Wide
GND1: testpoint09; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
HPF1: testpoint05; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
HPF2: testpoint15; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
HPF3: testpoint25; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
Output1: testpoint06; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
Output2: testpoint16; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
Output3: testpoint26; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
Power_supply1: 12 GND -12; FanPinHeader_1x03_P2.54mm_Vertical
R0, R10, R12: 5.1K; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R1, R2, R5, R6, R13, R14, R15, R16, R17, R18, R19, R20: 10K; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R3, R21, R23: 25K; Potentiometer_ACP_CA9-H3,8_Horizontal
R4, R22, R24: 12K; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R7, R8, R25, R26, R27, R28: 100K; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R9, R29, R30: 1k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R11, R31, R32: 2K; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R33, R34, R35: 20K; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
U1: L7809; FanPinHeader_1x03_P2.54mm_Vertical
U2, U3, U4: TL084; DIP-14_W7.62mm
U5: LM7909_TO220; FanPinHeader_1x03_P2.54mm_Vertical
Zener1: testpoint01; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
Zener2: testpoint11; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
Zener3: testpoint21; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
amp1: testpoint04; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
amp2: testpoint14; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
amp3: testpoint24; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
c1: 10u; CP_Radial_D5.0mm_P2.50mm
currentpoint1: testpoint02; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
currentpoint2: testpoint12; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
currentpoint3: testpoint22; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
rdt_mydaq1, rdt_mydaq2, rdt_mydaq3: Conn_01x01_Female; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
tamp_sensor_0, tamp_sensor_1, tamp_sensor_2: USW3426; FanPinHeader_1x03_P2.54mm_Vertical
temputure1: testpoint03; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
temputure2: testpoint13; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork
temputure3: testpoint23; Pin_D0.9mm_L10.0mm_W2.4mm_FlatFork

Connections:
9V: 9V1.1, C4.1, R0.1, R10.1, R12.1, U1.3, U2.4, U3.4, U4.4
-9V: 9V2.1, U2.11, U3.11, U4.11, U5.3, c1.2
/12V: C3.1, Power_supply1.3, U1.1
/-12V: C5.2, Power_supply1.1, U5.2
/Black01: R4.1, R7.2, U2.5, currentpoint1.1, tamp_sensor_0.2
/Black02: U2.10, tamp_sensor_0.3, temputure1.1
/Black11: R22.1, R25.2, U3.5, currentpoint2.1, tamp_sensor_1.2
/Black12: U3.10, tamp_sensor_1.3, temputure2.1
/Black21: R24.1, R26.2, U4.5, currentpoint3.1, tamp_sensor_2.2
/Black22: U4.10, tamp_sensor_2.3, temputure3.1
GND: C0.2, C1.2, C2.2, C3.2, C4.2, C5.1, Dzener_0.1, Dzener_1.1, Dzener_2.1, GND1.1, Power_supply1.2, R1.1, R11.2, R16.1, R18.1, R31.2, R32.2, U1.2, U5.1, c1.1, tamp_sensor_0.1, tamp_sensor_1.1, tamp_sensor_2.1
unnamed: C0.1, HPF1.1, R9.1, U2.12
unnamed: C1.1, HPF2.1, R29.1, U3.12
unnamed: C2.1, HPF3.1, R30.1, U4.12
unnamed: Dzener_0.2, R0.2, R6.1, Zener1.1
unnamed: Dzener_1.2, R10.2, R13.1, Zener2.1
unnamed: Dzener_2.2, R12.2, R14.1, Zener3.1
unnamed: Output1.1, R33.1, U2.14, rdt_mydaq1.1
unnamed: Output2.1, R34.1, U3.14, rdt_mydaq2.1
unnamed: Output3.1, R35.1, U4.14, rdt_mydaq3.1
unnamed: R1.2, R2.1, U2.2
unnamed: R2.2, R3.1, U2.1
unnamed: R3.2, R4.2
unnamed: R5.1, R6.2, U2.3
unnamed: R5.2, U2.6, U2.7
unnamed: R7.1, R8.2, U2.9
unnamed: R8.1, R9.2, U2.8, amp1.1
unnamed: R11.1, R33.2, U2.13
unnamed: R13.2, R15.1, U3.3
unnamed: R14.2, R17.1, U4.3
unnamed: R15.2, U3.6, U3.7
unnamed: R16.2, R19.1, U3.2
unnamed: R17.2, U4.6, U4.7
unnamed: R18.2, R20.1, U4.2
unnamed: R19.2, R21.1, U3.1
unnamed: R20.2, R23.1, U4.1
unnamed: R21.2, R22.2
unnamed: R23.2, R24.2
unnamed: R25.1, R27.2, U3.9
unnamed: R26.1, R28.2, U4.9
unnamed: R27.1, R29.2, U3.8, amp2.1
unnamed: R28.1, R30.2, U4.8, amp3.1
unnamed: R31.1, R34.2, U3.13
unnamed: R32.1, R35.2, U4.13

## KiCad design timing_circuit/timing_circuit.kicad_pcb

Parts:
C1, C17, C18: 330p; C_Rect_L7.0mm_W2.0mm_P5.00mm
C2: 0.47u; C_Rect_L7.0mm_W2.0mm_P5.00mm
C3, C4, C5, C6, C9, C10: 0.1u; C_Rect_L7.0mm_W2.0mm_P5.00mm
C7: 0.01u; C_Rect_L7.0mm_W2.0mm_P5.00mm
C8: 0.2u; C_Rect_L7.0mm_W2.0mm_P5.00mm
C11: 10uf; CP_Radial_D6.3mm_P2.50mm
C12, C13, C14, C15, C16: 10u; CP_Radial_D6.3mm_P2.50mm
D1: D; D_DO-201_P15.24mm_Horizontal
J1: jumper1; PinHeader_1x02_P2.54mm_Vertical
J2: jumper2; PinHeader_1x02_P2.54mm_Vertical
J3: jumper3; PinHeader_1x02_P2.54mm_Vertical
J5, J9: Conn_01x03_Female; PinHeader_1x03_P2.54mm_Vertical
LED_enable1: LED enable; PinHeader_1x01_P2.54mm_Vertical
Q1, Q2, Q3: 2N3904; TO-92_Inline
Quadratic_Output1: Quadratic Output; PinHeader_1x01_P2.54mm_Vertical
R1, R19: 50k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R2, R6, R9, R12, R20, R22: 100k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R3, R21: 200k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R4, R10: 4.7k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R5, R8, R11, R14, R18: 1k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R7, R13: 56k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R15, R16: 2k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
R17: 12k; R_Axial_DIN0309_L9.0mm_D3.2mm_P15.24mm_Horizontal
TP:_555_output1: TP - 555_output; PinHeader_1x01_P2.54mm_Vertical
TP:_+5V1: TP - +5V; PinHeader_1x01_P2.54mm_Vertical
TP:_+6V1: TP - +6V; PinHeader_1x01_P2.54mm_Vertical
TP:_+9V1: TP - +9V; PinHeader_1x01_P2.54mm_Vertical
TP:_+12V1: TP - +12V; PinHeader_1x01_P2.54mm_Vertical
TP:_-9V1: TP - -9V; PinHeader_1x01_P2.54mm_Vertical
TP:_-12V1: TP - -12V; PinHeader_1x01_P2.54mm_Vertical
TP:_AD630_out_x1: TP - AD630_out_x; PinHeader_1x01_P2.54mm_Vertical
TP:_AD630_out_y1: TP - AD630_out_y; PinHeader_1x01_P2.54mm_Vertical
TP:_GND1: TP - GND; PinHeader_1x01_P2.54mm_Vertical
TP:_HPF_x1: TP - HPF_x; PinHeader_1x01_P2.54mm_Vertical
TP:_HPF_y1: TP - HPF_y; PinHeader_1x01_P2.54mm_Vertical
TP:_amp_out1: TP - amp_out; PinHeader_1x01_P2.54mm_Vertical
TP:_clock1: TP - clock_0; PinHeader_1x01_P2.54mm_Vertical
TP:_clock_90: TP - clock_90; PinHeader_1x01_P2.54mm_Vertical
TP:_integrator_x1: TP - integrator_x; PinHeader_1x01_P2.54mm_Vertical
TP:_integrator_y1: TP - integrator_y; PinHeader_1x01_P2.54mm_Vertical
TP:_led_enable_input1: TP - led_enable_input; PinHeader_1x01_P2.54mm_Vertical
TP:_led_enable_output1: TP - led_enable_output; PinHeader_1x01_P2.54mm_Vertical
TP:_led_sensor(g)1: TP - led sensor(gnd); PinHeader_1x01_P2.54mm_Vertical
TP:_led_sensor(s)1: TP - led sensor(s); PinHeader_1x01_P2.54mm_Vertical
TP:_led_supply1: TP - led_supply; PinHeader_1x01_P2.54mm_Vertical
TP:_output_x1: TP - output_x; PinHeader_1x01_P2.54mm_Vertical
TP:_output_y1: TP - output_y; PinHeader_1x01_P2.54mm_Vertical
U1: LM555; DIP-8_W7.62mm_Socket
U2, U3: AD630ARZ; DIP-20_W7.62mm
U4: L7805; TO-220-3_Vertical
U5: TL084; DIP-14_W7.62mm
U6: 74LS74; DIP-14_W7.62mm
U7: LM7909_TO220; TO-220-3_Vertical
U8: 7402; DIP-14_W7.62mm_Socket
U9: L7809; TO-220-3_Vertical
U10: CA3140; DIP-8_W7.62mm_Socket
amp_input1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
in_Phase_Output1: In Phase Output; PinHeader_1x01_P2.54mm_Vertical
jumper1: jumper1; PinHeader_1x02_P2.54mm_Vertical
jumper2, jumper3: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
power_suplly_6V1: Conn_01x02_Female; BarrelJack_Horizontal

Connections:
+5V: C12.1, Q1.2 (B), Q1.3 (C), Q2.2 (B), Q2.3 (C), R15.1, TP:_+5V1.1, U1.4, U1.8, U4.3 (OUT), U6.1 (~R), U6.4 (~S), U6.10 (~S), U6.13 (~R), U6.14 (VCC), U8.14 (VCC)
+9V: C16.1, R4.1, R10.1, R18.2, TP:_+9V1.1, U2.11 (VS+), U3.11 (VS+), U5.4 (V+), U9.3 (OUT), U10.7 (V+)
-9V: C14.2, TP:_-9V1.1, U2.8 (VS-), U3.8 (VS-), U5.11 (V-), U7.3 (VO), U10.4 (V-)
/+6V: C11.1, TP:_+6V1.1, U4.1 (IN), power_suplly_6V1.1
/+12V: C15.1, J9.1, TP:_+12V1.1, U9.1 (IN)
/-12V: C13.2, J9.3, TP:_-12V1.1, U7.2 (VI)
GND: C4.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.1, C15.2, C16.2, J5.3, J9.2, Q3.1 (E), R3.1, R7.1, R8.1, R13.2, R14.1, R19.1, R20.1, TP:_GND1.1, U1.1, U2.10 (SEL_A), U2.14 (RB), U2.17 (RinB), U3.10 (SEL_A), U3.14 (RB), U3.17 (RinB), U4.2 (GND), U6.7 (GND), U7.1 (GND), U8.7 (GND), U9.2 (GND), power_suplly_6V1.2
unnamed: C1.1, C2.2, R1.1, R21.1, R22.1, U10.6
unnamed: C1.2, TP:_led_sensor(s)1.1, U10.2 (-), amp_input1.1, jumper1.2, jumper2.2, jumper3.2
unnamed: C2.1, TP:_amp_out1.1, U2.1 (RinA), U2.16 (RA), U3.1 (RinA), U3.16 (RA)
unnamed: C3.1, R2.1, R6.2, TP:_integrator_x1.1, U5.1
unnamed: C3.2, R2.2, R5.1, U5.2 (-)
unnamed: C4.2, R6.1, TP:_HPF_x1.1, U5.12 (+)
unnamed: C5.1, R9.1, R12.2, TP:_integrator_y1.1, U5.7
unnamed: C5.2, R9.2, R11.1, U5.6 (-)
unnamed: C6.2, R12.1, TP:_HPF_y1.1, U5.10 (+)
unnamed: C7.1, U1.5
unnamed: C8.1, D1.1 (K), R16.2, U1.2, U1.6
unnamed: C10.1, C17.1, TP:_clock_90.1, U6.5 (Q), U6.12 (D)
unnamed: C17.2, R13.1, U3.9 (SEL_B)
unnamed: C9.1, C18.1, TP:_clock1.1, U6.9 (Q), U8.2, U8.3
unnamed: C18.2, R7.2, U2.9 (SEL_B)
unnamed: D1.2 (A), R15.2, R16.1, U1.7
unnamed: J1.1, J2.1, J3.1, TP:_led_sensor(g)1.1, U10.3 (+), amp_input1.2
unnamed: J1.2, R19.2
unnamed: J2.2, R20.2
unnamed: J3.2, R3.2
unnamed: J5.1, Q1.1 (E), Q2.1 (E), TP:_led_supply1.1
unnamed: J5.2, Q3.3 (C), R18.1, TP:_led_enable_output1.1
unnamed: LED_enable1.1, TP:_led_enable_input1.1, U8.5
unnamed: Q3.2 (B), R17.1
unnamed: Quadratic_Output1.1, TP:_output_y1.1, U5.8, U5.9 (-)
unnamed: R1.2, jumper3.1
unnamed: R4.2, U2.7 (B/~A)
unnamed: R5.2, TP:_AD630_out_x1.1, U2.13 (Vout)
unnamed: R8.2, U5.3 (+)
unnamed: R10.2, U3.7 (B/~A)
unnamed: R11.2, TP:_AD630_out_y1.1, U3.13 (Vout)
unnamed: R14.2, U5.5 (+)
unnamed: R17.2, U8.4
unnamed: R21.2, jumper1.1
unnamed: R22.2, jumper2.1
unnamed: TP:_555_output1.1, U1.3, U6.3 (C), U6.11 (C)
unnamed: TP:_output_x1.1, U5.13 (-), U5.14, in_Phase_Output1.1
unnamed: U2.15 (RF), U2.19 (CHB-), U2.20 (CHA-)
unnamed: U3.15 (RF), U3.19 (CHB-), U3.20 (CHA-)
unnamed: U6.2 (D), U6.8 (~Q)
unnamed: U8.1, U8.6

Board: 2 copper layers, 91 parts (0 on the bottom side), 48 nets.

## Commit log

2020-11-18 added the latest kicad files, not that the projects are fixed but the gerber aand drill fiels arent
2020-11-23 Update README.md
    updated the readme file
2020-11-23 Add files via upload
    added the project presentation
